Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2016-12-07T15:30:34
Organization: WSP Finland
Made in: ASIFC - 2.5.4.645

# IfcProject
LongName: F1_HKR_puunsuoja_liikennealue

# IfcSite, Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcProxy (40)
ProxyType: PRODUCT
Name | Description
26 x KANNATINKEHIKKO | teräslevy, Pintakäsittely: kuumasinkitys
10 x PUUNSUOJA, liikennealue | Lattateräs, kuumasinkitys + sinkkifosfatointi + jauhemaalaus (tai vastaava yhdistelmä), väri RAL 7021
MAARITILÄ | Teräslevy, Pintakäsittely: kuumasinkitys + sinkkifosfatointi + jauhemaalaus (tai vastaava yhdistelmä)
3 x MAARITILÄ | kuumasinkitys + sinkkifosfatointi + jauhemaalaus (tai vastaava yhdistelmä)
